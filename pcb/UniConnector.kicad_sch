File: pcb/UniConnector.kicad_sch (KiCad schematic)
At the start: 17 parts

Commit message: Cleaning
Parts:
- X1: value ~ -> (none)
